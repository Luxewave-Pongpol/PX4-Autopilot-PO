## src/examples/px4_simple_app/Kconfig
```kconfig
menuconfig EXAMPLES_PX4_SIMPLE_APP
     bool "px4_simple_app"
     default n
     ---help---
     	Enable PX4 simple app
```
